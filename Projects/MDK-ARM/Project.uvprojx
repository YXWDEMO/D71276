# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32C642x5 Puya
  pack: Puya.PY32C642_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: PY32C642x5,USE_FULL_LL_DRIVER
  c include: ..\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\PY32C6xx\Include;..\..\Drivers\PY32C642_HAL_Driver\Inc;..\..\Drivers\BSP\PY32C642xx_Start_Kit;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xa00
  memory RVCT10: RAM 0x20000a00 size 0x200
  group Common
    ../Src/: system_py32c642.c
    ./: startup_py32c642xx.s
  group Application/User
    ../Src/: main.c py32c642_it.c
  group BSP/py32c642xx_Start_Kit
    ../../Drivers/BSP/PY32C642xx_Start_Kit/: py32c642xx_ll_Start_Kit.c
  group Drivers/PY32C642_HAL_Driver
    ../../Drivers/PY32C642_HAL_Driver/Src/: py32c642_ll_adc.c py32c642_ll_gpio.c py32c642_ll_rcc.c py32c642_ll_utils.c py32c642_ll_exti.c py32c642_hal_flash.c py32c642_hal.c py32c642_hal_cortex.c py32c642_ll_tim.c py32c642_ll_lptim.c
  group User
    ../../User/: ADC.c GPIO.c PWR.c FLASH.c TIM.c TIM.h LPTIM.c LPTIM.h Disp.c sys.c out.c portscan.c baterry.c Sleep.c SwitchDip.c ledIcRgb.c AiP33A06.c AiP33A06.h
